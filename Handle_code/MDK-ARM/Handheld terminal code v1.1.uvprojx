# Keil uVision project Handheld terminal code v1.1.uvprojx, settings and files
target Handheld terminal code v3.1 (ARM-ADS)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Handheld terminal code v1.1
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src/drivers;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;..\Hardware\OLED;..\Hardware\ECG;..\Hardware\SDCard;..\Hardware\RSP;..\Hardware\CO;..\Hardware\SHT75;..\Hardware\MS5611
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim.c stm32f4xx_hal_adc.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_sd.c stm32f4xx_hal_flash_ex.c
  group Application/Hardware
    ../Hardware/OLED/: oled.c
    ../Hardware/ECG/: ECG.c
    ../Hardware/SDCard/: SDCard.c
    ../Hardware/RSP/: RSP.c
    ../Hardware/CO/: CO.c
    ../Hardware/SHT75/: SHT75.C
    ../Hardware/MS5611/: MS5611.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/User
    ../Src/: main.c adc.c dma.c i2c.c tim.c rtc.c stm32f4xx_it.c usart.c stm32f4xx_hal_msp.c gpio.c bsp_driver_sd.c fatfs.c sdio.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group ReadMe
    ../: ReadMe.txt
software components: CMSIS:CORE 4.1.0
